Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: G:\Dokumente Oeffentlich\BIM 2D 3D\13_Wasseraufbereitung\3D\WL-D-100_With_Brinetank.IFC
Time: 2025-12-04T07:57:14+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project
